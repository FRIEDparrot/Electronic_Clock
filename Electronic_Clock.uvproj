# Keil uVision project Electronic_Clock.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Electronic_Clock +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\public;.\LED_function;.\Timer_function
  group Source Group 1
    ./: STARTUP.A51 main.c
  group public
    ./public/: public.h public.c
  group LED
    ./LED_function/: LED_controller.h LED_controller.c
  group Timer
    ./Timer_function/: timer_controller.h timer_controller.c
